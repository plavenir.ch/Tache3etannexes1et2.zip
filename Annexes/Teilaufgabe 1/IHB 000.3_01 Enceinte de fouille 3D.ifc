Properties of the parts of a building model (IFC2X3)

# File
Description: no view
File name: L.ifc
Time: 2026-08-27T15:51:07
Author: Besar Asani
Organization: No Organization
Written by: ODA SDAI 25.4
Authorization: b.asani

# IfcProject, 00'000 - Besar Asani
AllplanAttributes - Bauherr: Bauherr Name; Architekt: Architekt Name; Bauort: PLZ und Ort; Bauunternehmer Straße: Bauunternehmer Strasse; Bauunternehmer Plz/Ort: Bauunternehmer PLZ Ort; Bauherr Straße: Bauherr Strasse; Bauherr Plz/Ort: Bauherr PLZ Ort; Architekt Straße: Architekt Strasse; Architekt Plz/Ort: Architekt PLZ Ort; Projektbeschreibung: Projektbeschreibung; Bauunternehmer: Bauunternehmer Name

# IfcSite, Modelle auf dem Nullpunkt
RefLatitude: 48, 8, 10, 320000; RefLongitude: 11, 41, 19, 320000

# IfcBuildingElementProxy (3)
In: L
Name | Objektname | Text1 | Text2 | Bezeichnung = Typ = Elementbezeichnung | Barrierefrei = öffentlich zugänglich = Tragendes Bauteil | Attributset-Objekt | Allright_Bauteil_ID | Abrechnungsart | Status
Kontrollpunkt | Kontrollpunkt | X = 2695881.75 | Y = 1261014.30 | Kontrollpunkt | no | Body | 7508Kop0000000006 | m³ | Neubau
Kontrollpunkt | Kontrollpunkt | X = 2695833.95 | Y = 1261009.75 | Kontrollpunkt | no | Body | 7508Kop0000000008 | m³ | Neubau | AllplanAttributes - X_Koordinate: 0 m; Y_Koordinate: 0 m; Achsenendpunkt (X): 0 m
 | PythonPart |  |  |  |  |  | 7508Pyt0000000576 | St | AllplanAttributes - V6: 0 m; V7: 0 m; V8: 0 m; V9: 0; Plugin_Objektname: PythonPart; Abtrag: 0 m3; Auftrag: 0 m3; Steifemodul: 0; Reibungswinkel: 0; Feuchte Wichte: 0; Effektive Wichte: 0; Undränierte Kohäsion: 0; Dränierte Kohäsion: 0

# IfcElementAssembly, EPM_BaseReference
In: L
AllplanAttributes - Plugin_Objektname: PythonPart; Allright_Bauteil_ID: 7508Elg0000000579; Abrechnungsart: m³; Objektname: Makrogruppe
